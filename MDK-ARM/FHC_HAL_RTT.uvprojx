# Keil uVision project FHC_HAL_RTT.uvprojx, settings and files
target FHC_HAL_RTT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FHC_HAL_RTT +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Output\@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\RTT_Nano;..\RTT_Nano\shell;..\RTT_Nano\kernal;..\RTT_Nano\include;..\bsp;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/User
    ../Src/: main.c fhc_thread.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group bsp
    ../bsp/: bsp_clock.c bsp_dac.c bsp_gpio.c bsp_i2c.c bsp_rtc.c bsp_spi.c bsp_timer.c bsp_uart.c bsp_max31856.c bsp_hc595.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group RTT
    ../RTT_Nano/: board.c rtconfig.h
    ../RTT_Nano/shell/: cmd.c finsh.h finsh_api.h msh.c msh.h shell.c shell.h
    ../RTT_Nano/kernal/: clock.c components.c context_rvds.S cpuport.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
software components: CMSIS:CORE 4.3.0
